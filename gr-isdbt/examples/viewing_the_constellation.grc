options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: viewing_the_constellation
    output_language: python
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '545143000'
  states: {}
- name: cur_iq_view_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@2
    label: View
    label0: Magnitude
    label1: I
    label2: Q
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '8'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rate_corr
  id: variable_qtgui_range
  parameters:
    label: Rate correction
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rfgain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.4e6*80/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: active_carriers
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: active_carriers
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ch_taps
    type: complex
    vlen: active_carriers
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/supply_crate
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: cur_iq_view_mode
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: active_carriers
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: active_carriers
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(active_carriers)
  states: {state: disabled}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: mode
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/(samp_rate+rate_corr)
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@0
    size: active_carriers
    type: complex
    update_time: 1.0/20.0
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Incoming spectrum"'
    showports: 'True'
    type: complex
    update_time: 1.0/20.0
  states: {}
- name: qtgui_number_sink_fe
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Frequency Error"'
    type: float
  states: {}
- name: qtgui_number_sink_se
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0.1'
    min: '-0.1'
    name: '"Sampling Rate Error"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: tab@2
    label1: ''
    legend: 'False'
    name: '"Channel gain (frequency)"'
    size: active_carriers
    srate: samp_rate
    type: float
    update_time: 1.0/20.0
    ymax: '7'
    ymin: '-7'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    label2: ''
    name: '"Channel taps"'
    size: active_carriers
    srate: samp_rate*active_carriers/total_carriers
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@3
    label1: ''
    legend: 'False'
    marker1: '0'
    name: '"Pilot gain (frequency)"'
    size: active_carriers
    srate: samp_rate
    style1: '0'
    type: float
    update_time: 1.0/20.0
    ymax: '10'
    ymin: '0'
  states: {}
- name: reset
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna B
    bandwidth: '7000000'
    center_freq: center_freq
    gain: gain
    lna_state: rfgain
    samp_rate: samp_rate+rate_corr
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Constellation
    label1: Spectrum
    label2: Estimated channel
    label3: Pilot gain
    num_tabs: '4'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_selector_0, '1']
- [blocks_complex_to_float_0, '1', blocks_selector_0, '2']
- [blocks_complex_to_mag_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_selector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_throttle2_0, '0', mmse_resampler_xx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_complex_to_float_0, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_complex_to_mag_0, '0']
- [isdbt_ofdm_synchronization_0, '1', blocks_file_sink_0, '0']
- [isdbt_ofdm_synchronization_0, '1', fft_vxx_0_0, '0']
- [isdbt_ofdm_synchronization_0, '2', blocks_vector_to_stream_0_1, '0']
- [isdbt_ofdm_synchronization_0, '3', qtgui_number_sink_fe, '0']
- [isdbt_ofdm_synchronization_0, '4', qtgui_number_sink_se, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [reset, pressed, isdbt_ofdm_synchronization_0, reset]
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
