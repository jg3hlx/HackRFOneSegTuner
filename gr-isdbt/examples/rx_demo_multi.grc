options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rx_demo_multi
    output_language: python
    title: '"Multi-Layer RX Demo"'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '509143000'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    rangeType: int
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '8'
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rate_corr
  id: variable_qtgui_range
  parameters:
    label: Rate correction
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rfgain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*(64/63)
  states: {}
- name: source_rate
  id: variable
  parameters:
    value: 7e6
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/result_layer_b.ts
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/result_layer_a.ts
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/result_layer_c.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/supply_crate
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: active_carriers
    type: complex
  states: {}
- name: isdbt_bit_deinterleaver_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    layer: '1'
    mode: mode
    segments: '6'
  states: {}
- name: isdbt_bit_deinterleaver_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '4'
    layer: '0'
    mode: mode
    segments: '1'
  states: {}
- name: isdbt_bit_deinterleaver_0_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '16'
    layer: '2'
    mode: mode
    segments: '6'
  states: {}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_deinterleaver_0_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_deinterleaver_0_0_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0_0_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: mode
    oneseg: 'True'
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: mode
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0_0_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '4'
    constellation_size_B: '64'
    constellation_size_C: '16'
    mode: mode
    segments_A: '1'
    segments_B: '6'
    segments_C: '6'
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '4'
    length_B: '2'
    length_C: '0'
    mode: mode
    segments_A: '1'
    segments_B: '12'
    segments_C: '0'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: mode
    print_params: 'False'
  states: {}
- name: isdbt_viterbi_decoder_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '64'
    layer: '1'
    rate: '0'
  states: {}
- name: isdbt_viterbi_decoder_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '4'
    layer: '0'
    rate: '0'
  states: {}
- name: isdbt_viterbi_decoder_0_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '16'
    layer: '2'
    rate: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_BLACKMAN
  states: {}
- name: note_0
  id: note
  parameters:
    note: Layer A
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Layer B
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Layer C
  states: {}
- name: ofdm_reset
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: post_ber_a
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"post-BER (A)"'
    type: float
  states: {}
- name: post_ber_b
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"post-BER (B)"'
    type: float
  states: {}
- name: post_ber_c
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-10'
    name: '"post-BER (C)"'
    type: float
  states: {}
- name: pre_ber_a
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-5'
    name: '"pre-BER (A)"'
    type: float
  states: {}
- name: pre_ber_b
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-5'
    name: '"pre-BER (B)"'
    type: float
  states: {}
- name: pre_ber_c
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-5'
    name: '"pre-BER (C)"'
    type: float
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: show_stats@0
    size: active_carriers
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: show_stats@1
    type: complex
    ymin: '-120'
  states: {}
- name: show_stats
  id: qtgui_tab_widget
  parameters:
    label0: Constellation
    label1: Spectrum
    num_tabs: '2'
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import os
      import subprocess

      for i in ["/tmp/result_layer_a.ts", "/tmp/result_layer_b.ts", "/tmp/result_layer_c.ts"]:
        if os.path.exists(i):
          os.remove(i)
        
        os.mkfifo(i)

      global playerProc1
      global playerProc2
      global playerProc3

      playerProc1=subprocess.Popen(['ffplay','-loglevel','quiet','-infbuf','-i','/tmp/result_layer_a.ts'])
      playerProc2=subprocess.Popen(['ffplay','-loglevel','quiet','-infbuf','-i','/tmp/result_layer_b.ts'])
      playerProc3=subprocess.Popen(['ffplay','-loglevel','quiet','-infbuf','-i','/tmp/result_layer_c.ts'])
    comment: create the fifo
    section: init_before_blocks
  states: {state: disabled}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      playerProc1.terminate()
      playerProc2.terminate()
      playerProc3.terminate()
    section: main_after_stop
  states: {state: disabled}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna B
    bandwidth: '7000000'
    center_freq: center_freq+freq_offset
    gain: gain
    lna_state: rfgain
    samp_rate: samp_rate+rate_corr
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_nlog10_ff_0, '0', post_ber_b, '0']
- [blocks_nlog10_ff_0_0, '0', pre_ber_b, '0']
- [blocks_nlog10_ff_0_0_0, '0', pre_ber_a, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', pre_ber_c, '0']
- [blocks_nlog10_ff_0_1, '0', post_ber_a, '0']
- [blocks_nlog10_ff_0_1_0, '0', post_ber_c, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_const_sink_x_1, '0']
- [isdbt_bit_deinterleaver_0, '0', isdbt_viterbi_decoder_0, '0']
- [isdbt_bit_deinterleaver_0, changed, isdbt_byte_deinterleaver_0, reset]
- [isdbt_bit_deinterleaver_0, changed, isdbt_energy_descrambler_0, reset]
- [isdbt_bit_deinterleaver_0_0, '0', isdbt_viterbi_decoder_0_0, '0']
- [isdbt_bit_deinterleaver_0_0, changed, isdbt_energy_descrambler_0_0, reset]
- [isdbt_bit_deinterleaver_0_0_0, '0', isdbt_viterbi_decoder_0_0_0, '0']
- [isdbt_bit_deinterleaver_0_0_0, changed, isdbt_energy_descrambler_0_0_0, reset]
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_deinterleaver_0_0, '0', isdbt_energy_descrambler_0_0, '0']
- [isdbt_byte_deinterleaver_0_0_0, '0', isdbt_energy_descrambler_0_0_0, '0']
- [isdbt_energy_descrambler_0, '0', isdbt_reed_solomon_dec_isdbt_0, '0']
- [isdbt_energy_descrambler_0_0, '0', isdbt_reed_solomon_dec_isdbt_0_0, '0']
- [isdbt_energy_descrambler_0_0_0, '0', isdbt_reed_solomon_dec_isdbt_0_0_0, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_vector_to_stream_1, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '1', blocks_nlog10_ff_0_1, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0_0, '1', blocks_nlog10_ff_0_1_0, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0_0, '0']
- [isdbt_symbol_demapper_0, '1', isdbt_bit_deinterleaver_0, '0']
- [isdbt_symbol_demapper_0, '2', isdbt_bit_deinterleaver_0_0_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [isdbt_tmcc_decoder_0, ofdm reset, isdbt_ofdm_synchronization_0, reset]
- [isdbt_tmcc_decoder_0, params, isdbt_bit_deinterleaver_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_bit_deinterleaver_0_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_bit_deinterleaver_0_0_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_symbol_demapper_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_time_deinterleaver_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_viterbi_decoder_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_viterbi_decoder_0_0, params]
- [isdbt_tmcc_decoder_0, params, isdbt_viterbi_decoder_0_0_0, params]
- [isdbt_viterbi_decoder_0, '0', isdbt_byte_deinterleaver_0, '0']
- [isdbt_viterbi_decoder_0, '1', single_pole_iir_filter_xx_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '0', isdbt_byte_deinterleaver_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '1', single_pole_iir_filter_xx_0_0_0, '0']
- [isdbt_viterbi_decoder_0_0_0, '0', isdbt_byte_deinterleaver_0_0_0, '0']
- [isdbt_viterbi_decoder_0_0_0, '1', single_pole_iir_filter_xx_0_0_0_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [ofdm_reset, pressed, isdbt_ofdm_synchronization_0, reset]
- [single_pole_iir_filter_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
