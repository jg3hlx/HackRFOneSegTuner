options:
  parameters:
    author: flarroca
    generate_options: qt_gui
    id: obtaining_the_parameters
    output_language: python
    title: Synchronization
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: center frequency
    type: real
    value: '485143000'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '8'
  states: {}
- name: guard
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Guard Interval
    label0: 1/4
    label1: 1/8
    label2: 1/16
    label3: 1/32
    num_opts: '4'
    option0: 1/4.0
    option1: 1/8.0
    option2: 1/16.0
    option3: 1/32.0
    orient: Qt.QHBoxLayout
    type: real
    value: 1/8
    widget: radio_buttons
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Mode
    label0: Mode 3 (8K)
    label1: Mode 2 (4K)
    label2: Mode 1 (2K)
    num_opts: '3'
    option0: '3'
    option1: '2'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: rate_corr
  id: variable_qtgui_range
  parameters:
    label: Rate correction
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '4'
  states: {}
- name: rfgain
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*(64/63)
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(mode+10)
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: total_carriers
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(guard*total_carriers)
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: ((1+guard)*total_carriers)/1024
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'FIRST: Try different values of mode and guard until you see a clear peak '
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,5,1
    name: '"Autocorrelation with a delay of total_carriers"'
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    type: float
    update_time: 1.0/30.0
    ymax: '2'
    ymin: '0'
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna B
    bandwidth: samp_rate
    bias: 'False'
    center_freq: center_freq
    gain: gain
    lna_state: rfgain
    samp_rate: samp_rate+rate_corr
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_1, '0', mmse_resampler_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
